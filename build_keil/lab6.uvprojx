# Keil uVision project lab6.uvprojx, settings and files
target Test_HWWDT (6240000::V6.24::ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.6.0
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test_HWWDT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _Test_HWWDT_
  c include: ..\src;..\hal\include;..\bsp\include;..\shared\includes
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ../src/: main.c isr.c
  group test
    ../test/: test_hwwdt.c test_hwwdt_isr.c
  group shared
    ../shared/lib/: 30319_shared.lib
  group bsp
    ../bsp/src/: FM4_leds_sw.c FM4_WM8731.c
  group hal
    ../hal/src/: HAL_SysTick.c HAL_FM4_gpio.c HAL_FM4_i2c.c HAL_FM4_i2s.c HAL_FM4_hwwdt.c
target lab6 (6240000::V6.24::ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.6.0
  cpu: as above
  output: lab6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _LAB3_DEBUG_
  c include: ..\src;..\hal\include;..\bsp\include;..\shared\includes
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
